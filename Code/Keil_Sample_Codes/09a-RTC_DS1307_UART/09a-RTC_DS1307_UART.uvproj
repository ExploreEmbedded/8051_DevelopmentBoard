# Keil uVision project 09a-RTC_DS1307_UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 09a-RTC_DS1307_UART
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\00-libfiles
  group Source Group 1
    ./: main.c
    ../00-libfiles/: delay.c delay.h i2c.c i2c.h rtc.c rtc.h stdutils.h uart.c uart.h
