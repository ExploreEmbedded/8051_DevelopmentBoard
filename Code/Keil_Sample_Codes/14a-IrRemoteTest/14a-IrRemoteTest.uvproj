# Keil uVision project 14a-IrRemoteTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: 14a-IrRemoteTest +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\00-libfiles
  group Source Group 1
    ./: main.c
    ../00-libfiles/: delay.c delay.h gpio.c gpio.h lcd.c lcd.h stdutils.h
