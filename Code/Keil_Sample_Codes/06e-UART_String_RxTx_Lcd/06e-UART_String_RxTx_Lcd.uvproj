# Keil uVision project 06e-UART_String_RxTx_Lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 06e-UART_String_RxTx_Lcd
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\00-libfiles
  group Source Group 1
    ./: main.c
    ../00-libfiles/: delay.c delay.h gpio.c gpio.h lcd.c lcd.h stdutils.h uart.c uart.h
