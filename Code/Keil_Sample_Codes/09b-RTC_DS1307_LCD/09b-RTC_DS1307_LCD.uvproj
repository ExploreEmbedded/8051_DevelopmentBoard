# Keil uVision project 09b-RTC_DS1307_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 09b-RTC_DS1307_LCD
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\00-libfiles
  group Source Group 1
    ./: main.c
    ../00-libfiles/: rtc.h stdutils.h delay.c delay.h gpio.c gpio.h i2c.c i2c.h lcd.c lcd.h rtc.c
