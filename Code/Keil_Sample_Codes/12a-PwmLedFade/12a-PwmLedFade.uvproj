# Keil uVision project 12a-PwmLedFade.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 12a-PwmLedFade +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\00-libfiles
  group Source Group 1
    ./: main.c pwm.c pwm.h
    ../00-libfiles/: delay.h stdutils.h delay.c
