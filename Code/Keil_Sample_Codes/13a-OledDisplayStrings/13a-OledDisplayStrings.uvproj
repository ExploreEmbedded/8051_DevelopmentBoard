# Keil uVision project 13a-OledDisplayStrings.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: 13a-OledDisplayStrings +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\00-libfiles
  group Source Group 1
    ../00-libfiles/: oled_i2c.c oled_i2c.h stdutils.h
    ./: main.c
