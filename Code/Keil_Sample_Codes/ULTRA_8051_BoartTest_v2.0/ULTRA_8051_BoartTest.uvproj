# Keil uVision project ULTRA_8051_BoartTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: ULTRA_8051_BoartTest +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\00-libfiles
  group SourceFiles
    ../00-libfiles/: adc.c adc.h delay.c delay.h eeprom.c eeprom.h gpio.c gpio.h i2c.c i2c.h keypad.c keypad.h lcd.c lcd.h rtc.c rtc.h stdutils.h uart.c uart.h
    ./: main.c
